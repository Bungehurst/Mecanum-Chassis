# Keil uVision project Micro-car.uvprojx, settings and files
target Micro-car (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Micro-car +hex
  c flags: Optim=7 uC99=1 wLevel=3
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\BSP\pwm;..\BSP\usart;..\APP;..\BSP\timer;..\BSP;..\BSP\led;..\APP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CORE
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_dma.c
  group BSP
    ../BSP/: BSP.c
    ../BSP/pwm/: pwm.c
    ../BSP/timer/: timer.c
    ../BSP/usart/: usart1.c usart2.c usart3.c
  group APP
    ../APP/: APP.c pid.c
  group USER
    ./: main.c
software components: CMSIS:CORE 5.0.1
